<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>main_turbo</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len</value></param>
<param><key>value</key><value>(T_bch+len(bs_slots)*(T_s+T_g)+T_p)/float(1000)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>2450e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Frequency Offset (Multiples of Sub-carrier spacing)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-.1</value></param>
<param><key>step</key><value>.00001</value></param>
<param><key>stop</key><value>.1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>9</value></param>
<param><key>label</key><value>Absolute Gain</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>l</value></param>
<param><key>comment</key><value>OUT = (64*32)+(1+(IN+16)/8)*4*137+(1+int((1+(IN+16)/8)*4/5))*137</value></param>
<param><key>value</key><value>(64*32)+(1+(nbits+16)/8)*4*137+(1+(1+(nbits+16)/8)*4/5)*137</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>n</value></param>
<param><key>value</key><value>35</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbits</value></param>
<param><key>value</key><value>16*8</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise_voltage</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Noise Amplitude</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>5</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>taps phase</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>.01</value></param>
<param><key>stop</key><value>2*3.14</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>int(1e6)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>time_offset</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.995</value></param>
<param><key>step</key><value>0.00001</value></param>
<param><key>stop</key><value>1.005</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Processing duration (ms)</value></param>
<param><key>value</key><value>500</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_2</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.make_dict(), pmt.init_u8vector(1,[1]))</value></param>
<param><key>period</key><value>.01</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>128</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_2_2</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0_0</value></param>
<param><key>host</key><value>127.0.0.1</value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52002</value></param>
<param><key>tcp_no_delay</key><value>True</value></param>
<param><key>type</key><value>"UDP_CLIENT"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>comment</key><value>I made the packets bigger 
in order to make less handler calls</value></param>
<param><key>len_tag_key</key><value>"packet_len2"</value></param>
<param><key>packet_len</key><value>l/4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>label</key><value>BS Slots</value></param>
<param><key>value</key><value>range(1)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>control</value></param>
<param><key>label</key><value>Access control</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>none</value></param>
</block>
<block>
<key>ephyl_bs_scheduler</key>
<param><key>id</key><value>ephyl_bs_scheduler_0</value></param>
<param><key>bch_time</key><value>T_bch</value></param>
<param><key>exit_frame</key><value>0</value></param>
<param><key>guard_time</key><value>T_g</value></param>
<param><key>num_slots</key><value>len(bs_slots)</value></param>
<param><key>UHD</key><value>True</value></param>
<param><key>Proc_time</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>Slot_time</key><value>T_s</value></param>
</block>
<block>
<key>ephyl_data_and_access_control</key>
<param><key>id</key><value>ephyl_data_and_access_control_0</value></param>
<param><key>Control</key><value>control</value></param>
<param><key>activation_rate</key><value>1</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>save_log</key><value>False</value></param>
</block>
<block>
<key>ephyl_msg_mux</key>
<param><key>id</key><value>ephyl_msg_mux_0</value></param>
</block>
<block>
<key>ephyl_sn_scheduler</key>
<param><key>id</key><value>ephyl_sn_scheduler_0</value></param>
<param><key>bch_time</key><value>T_bch</value></param>
<param><key>guard_time</key><value>T_g</value></param>
<param><key>length_tag_key</key><value>"packet_len2"</value></param>
<param><key>num_slots</key><value>len(bs_slots)</value></param>
<param><key>phy_option</key><value>1</value></param>
<param><key>Proc_time</key><value>T_p</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>Slot_time</key><value>T_s</value></param>
<param><key>wanted_tag</key><value>'corr_est'</value></param>
</block>
<block>
<key>ephyl_tag_2_msg_char</key>
<param><key>id</key><value>ephyl_tag_2_msg_char_0</value></param>
<param><key>wanted_tag</key><value>"FRAME"</value></param>
</block>
<block>
<key>ephyl_tag_2_msg_char</key>
<param><key>id</key><value>ephyl_tag_2_msg_char_0_0</value></param>
<param><key>wanted_tag</key><value>'PUSCH'</value></param>
</block>
<block>
<key>ephyl_turbofsk_rx</key>
<param><key>id</key><value>ephyl_turbofsk_rx_0</value></param>
<param><key>NbBits</key><value>nbits</value></param>
<param><key>Noise</key><value>n</value></param>
</block>
<block>
<key>ephyl_turbofsk_tx</key>
<param><key>id</key><value>ephyl_turbofsk_tx_0</value></param>
<param><key>NbBits</key><value>nbits</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, sys, numpy as np, random, string</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>Packet Error rate</value></param>
<param><key>size</key><value>64</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ylabel</key><value>PER</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1_0_0_0_0_0_0_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>res</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>ref</value></param>
<param><key>name</key><value>BS</value></param>
<param><key>size</key><value>int(samp_rate*frame_len)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>tr_tag</key><value>BCH</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>40</value></param>
<param><key>ymin</key><value>-40</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_1_0_0_0_0_0_0_0_0_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>res</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>ref</value></param>
<param><key>name</key><value>BS</value></param>
<param><key>size</key><value>int(samp_rate*frame_len)</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_level</key><value>0.1</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>BCH</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>40</value></param>
<param><key>ymin</key><value>-40</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>txbits</value></param>
<param><key>size</key><value>16*2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>size</key><value>16*8</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>tr_tag</key><value>packet_len</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>140</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>res</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>bs_tags</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0</value></param>
<param><key>stream_id</key><value>iq_tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0</value></param>
<param><key>stream_id</key><value>busy</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>array</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>bcn</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>DL</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_1</value></param>
<param><key>stream_id</key><value>packet_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>res</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0</value></param>
<param><key>stream_id</key><value>busy</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_1</value></param>
<param><key>stream_id</key><value>iq_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_2</value></param>
<param><key>stream_id</key><value>array</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_2_1</value></param>
<param><key>stream_id</key><value>packet_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_2_2</value></param>
<param><key>stream_id</key><value>DL</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_2_2_0</value></param>
<param><key>stream_id</key><value>DL</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_3</value></param>
<param><key>stream_id</key><value>bcn</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_3_0</value></param>
<param><key>stream_id</key><value>bs_tags</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>ephyl_turbofsk_rx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>ephyl_turbofsk_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>ephyl_tag_2_msg_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>ephyl_tag_2_msg_char_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>virtual_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0_0</sink_block_id><source_key>strobe</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1_0_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_2_2</source_block_id><sink_block_id>ephyl_turbofsk_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>pdus</source_key><sink_key>data</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>ephyl_sn_scheduler_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0_0_0</sink_block_id><source_key>bcn</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_1_0_0_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_data_and_access_control_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0_0</sink_block_id><source_key>Array</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_data_and_access_control_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>Data</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ephyl_data_and_access_control_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>PER</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ephyl_msg_mux_0</source_block_id><sink_block_id>blocks_message_debug_2</sink_block_id><source_key>final_msg</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>ephyl_msg_mux_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>final_msg</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ephyl_sn_scheduler_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0</sink_block_id><source_key>busy</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_sn_scheduler_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_tag_2_msg_char_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>slot_msg</source_key><sink_key>frame_n</sink_key></connection>
<connection><source_block_id>ephyl_tag_2_msg_char_0_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>slot_msg</source_key><sink_key>slot_n</sink_key></connection>
<connection><source_block_id>ephyl_turbofsk_rx_0</source_block_id><sink_block_id>virtual_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_turbofsk_tx_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_turbofsk_tx_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ephyl_bs_scheduler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0</source_block_id><sink_block_id>ephyl_data_and_access_control_0</sink_block_id><source_key>out</source_key><sink_key>busy</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2</source_block_id><sink_block_id>ephyl_sn_scheduler_0</sink_block_id><source_key>out</source_key><sink_key>slot</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2_1</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2_1</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2_2</source_block_id><sink_block_id>ephyl_sn_scheduler_0</sink_block_id><source_key>out</source_key><sink_key>trig</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2_2_0</source_block_id><sink_block_id>ephyl_data_and_access_control_0</sink_block_id><source_key>out</source_key><sink_key>DL</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_3</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_3_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
