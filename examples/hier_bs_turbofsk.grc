<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_bs_turbofsk</value></param>
<param><key>author</key><value>Othmane Oubejja, CEA leti</value></param>
<param><key>category</key><value>[ephyl]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>IoT BS Emulator (TurboFSK PHY)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbits</value></param>
<param><key>value</key><value>16*8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Proc duration (ms)</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>UHD</value></param>
<param><key>label</key><value>Over the air</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_float_to_char</key>
<param><key>id</key><value>blocks_float_to_char_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_1</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>packet_len</value></param>
<param><key>align_output</key><value>True</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>label</key><value>BS Slots</value></param>
<param><key>value</key><value>range(5)</value></param>
</block>
<block>
<key>ephyl_bs_scheduler</key>
<param><key>id</key><value>ephyl_bs_scheduler_0</value></param>
<param><key>bch_time</key><value>T_bch</value></param>
<param><key>exit_frame</key><value>exit_frame</value></param>
<param><key>guard_time</key><value>T_g</value></param>
<param><key>num_slots</key><value>len(bs_slots)</value></param>
<param><key>UHD</key><value>UHD</value></param>
<param><key>Proc_time</key><value>T_p</value></param>
<param><key>samp_rate</key><value>int(samp_rate)</value></param>
<param><key>Slot_time</key><value>T_s</value></param>
</block>
<block>
<key>ephyl_msg_mux</key>
<param><key>id</key><value>ephyl_msg_mux_0</value></param>
</block>
<block>
<key>ephyl_tag_2_msg_char</key>
<param><key>id</key><value>ephyl_tag_2_msg_char_0</value></param>
<param><key>wanted_tag</key><value>"FRAME"</value></param>
</block>
<block>
<key>ephyl_tag_2_msg_char</key>
<param><key>id</key><value>ephyl_tag_2_msg_char_0_0</value></param>
<param><key>wanted_tag</key><value>'PUSCH'</value></param>
</block>
<block>
<key>ephyl_turbofsk_rx</key>
<param><key>id</key><value>ephyl_turbofsk_rx_0</value></param>
<param><key>NbBits</key><value>nbits</value></param>
<param><key>Noise</key><value>n</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>exit_frame</value></param>
<param><key>label</key><value>Exit Frame</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, sys, numpy as np, random</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>n</value></param>
<param><key>label</key><value>Noise Variance</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>35</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>DL</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>BCH</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>BS Frame</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>UL</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0_0</value></param>
<param><key>stream_id</key><value>bs_tags</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_1</value></param>
<param><key>stream_id</key><value>packet_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_2_1</value></param>
<param><key>stream_id</key><value>packet_rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_3_0</value></param>
<param><key>stream_id</key><value>bs_tags</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>ephyl_turbofsk_rx_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>virtual_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>ephyl_turbofsk_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>ephyl_tag_2_msg_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_char_0</source_block_id><sink_block_id>ephyl_tag_2_msg_char_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_1</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>pdus</source_key><sink_key>data</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>bcn</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_bs_scheduler_0</source_block_id><sink_block_id>pad_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_msg_mux_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>final_msg</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_tag_2_msg_char_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>slot_msg</source_key><sink_key>frame_n</sink_key></connection>
<connection><source_block_id>ephyl_tag_2_msg_char_0_0</source_block_id><sink_block_id>ephyl_msg_mux_0</sink_block_id><source_key>slot_msg</source_key><sink_key>slot_n</sink_key></connection>
<connection><source_block_id>ephyl_turbofsk_rx_0</source_block_id><sink_block_id>virtual_sink_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ephyl_bs_scheduler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2_1</source_block_id><sink_block_id>blocks_repack_bits_bb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_3_0</source_block_id><sink_block_id>blocks_float_to_char_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
