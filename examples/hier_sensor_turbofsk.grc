<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>hier_sensor_turbofsk</value></param>
<param><key>author</key><value>Othmane Oubejja, CEA leti</value></param>
<param><key>category</key><value>[ephyl]</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>IoT Sensor emulator (TurboFSK PHY)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>l</value></param>
<param><key>comment</key><value>OUT = (64*32)+(1+(IN+16)/8)*4*137+(1+int((1+(IN+16)/8)*4/5))*137
for nbits = IN = 128 bits --&gt; OUT = 14652</value></param>
<param><key>value</key><value>(64*32)+(1+(nbits+16)/8)*4*137+(1+(1+(nbits+16)/8)*4/5)*137</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nbits</value></param>
<param><key>value</key><value>16*8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_bch</value></param>
<param><key>label</key><value>BCH duration (ms)</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_g</value></param>
<param><key>label</key><value>Guard time duration (ms)</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_p</value></param>
<param><key>label</key><value>Proc duration (ms)</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>T_s</value></param>
<param><key>label</key><value>Slot duration (ms)</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>activation_rate</value></param>
<param><key>label</key><value>Activation Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_1</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>const</key><value>128</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_2_2</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value>"packet_len"</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet_len2"</value></param>
<param><key>packet_len</key><value>l/4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bs_slots</value></param>
<param><key>label</key><value>BS Slots</value></param>
<param><key>value</key><value>range(5)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>control</value></param>
<param><key>label</key><value>Slot Access Policy</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>all</value></param>
</block>
<block>
<key>ephyl_data_and_access_control</key>
<param><key>id</key><value>ephyl_data_and_access_control_0</value></param>
<param><key>Control</key><value>control</value></param>
<param><key>activation_rate</key><value>activation_rate</value></param>
<param><key>bs_slots</key><value>bs_slots</value></param>
<param><key>save_log</key><value>log</value></param>
</block>
<block>
<key>ephyl_sn_scheduler</key>
<param><key>id</key><value>ephyl_sn_scheduler_0_0</value></param>
<param><key>bch_time</key><value>T_bch</value></param>
<param><key>comment</key><value>PHY Option:
0 = SC-FDMA
1 = TurboFSK</value></param>
<param><key>guard_time</key><value>T_g</value></param>
<param><key>length_tag_key</key><value>"packet_len2"</value></param>
<param><key>num_slots</key><value>len(bs_slots)</value></param>
<param><key>phy_option</key><value>1</value></param>
<param><key>Proc_time</key><value>T_p</value></param>
<param><key>samp_rate</key><value>int(samp_rate)</value></param>
<param><key>Slot_time</key><value>T_s</value></param>
<param><key>wanted_tag</key><value>'corr_est'</value></param>
</block>
<block>
<key>ephyl_turbofsk_tx</key>
<param><key>id</key><value>ephyl_turbofsk_tx_0</value></param>
<param><key>NbBits</key><value>nbits</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math, sys, numpy as np, random,string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>log</value></param>
<param><key>label</key><value>Generate log file</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>PER</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>UL</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>DL</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0_0</value></param>
<param><key>label</key><value>BCN</value></param>
<param><key>optional</key><value>True</value></param>
<param><key>type</key><value>message</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0</value></param>
<param><key>stream_id</key><value>iq_tx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0</value></param>
<param><key>stream_id</key><value>busy</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0_0</value></param>
<param><key>stream_id</key><value>array</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0_0_0</value></param>
<param><key>stream_id</key><value>DL</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_1_0_0_0_0_0</value></param>
<param><key>stream_id</key><value>BCN</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0</value></param>
<param><key>stream_id</key><value>busy</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_1</value></param>
<param><key>stream_id</key><value>iq_tx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_2</value></param>
<param><key>stream_id</key><value>array</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_4</value></param>
<param><key>stream_id</key><value>DL</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_2_0_4_0</value></param>
<param><key>stream_id</key><value>BCN</value></param>
</block>
<connection><source_block_id>blocks_float_to_complex_1</source_block_id><sink_block_id>virtual_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>pad_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_2_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0_0</source_block_id><sink_block_id>pad_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_2_2</source_block_id><sink_block_id>ephyl_turbofsk_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>ephyl_sn_scheduler_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_data_and_access_control_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0_0</sink_block_id><source_key>Array</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_data_and_access_control_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>Data</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ephyl_data_and_access_control_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0_0</sink_block_id><source_key>PER</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ephyl_sn_scheduler_0_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0</sink_block_id><source_key>busy</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ephyl_sn_scheduler_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_turbofsk_tx_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ephyl_turbofsk_tx_0</source_block_id><sink_block_id>blocks_float_to_complex_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pad_source_0_0</source_block_id><sink_block_id>virtual_sink_0_1_0_0_0_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0</source_block_id><sink_block_id>ephyl_data_and_access_control_0</sink_block_id><source_key>out</source_key><sink_key>busy</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_2</source_block_id><sink_block_id>ephyl_sn_scheduler_0_0</sink_block_id><source_key>out</source_key><sink_key>slot</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_4</source_block_id><sink_block_id>ephyl_data_and_access_control_0</sink_block_id><source_key>out</source_key><sink_key>DL</sink_key></connection>
<connection><source_block_id>virtual_source_1_2_0_4_0</source_block_id><sink_block_id>ephyl_sn_scheduler_0_0</sink_block_id><source_key>out</source_key><sink_key>trig</sink_key></connection>
</flow_graph>
